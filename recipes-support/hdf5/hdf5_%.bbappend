FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

EXTRA_OECMAKE:append = "-DHDF5_BUILD_TOOLS=OFF"
