FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Increase-sprintf-buffer-size.patch \
            "

