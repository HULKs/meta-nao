FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-SystemCallArchitecture-is-x86-and-x86-64-for-udev.patch"
