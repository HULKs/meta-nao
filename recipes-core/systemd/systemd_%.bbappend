FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Do-not-filter-system-calls-for-architecture-native-i.patch"

